# Keil uVision project CameraModule.uvprojx, settings and files
target STM32F429ZIT6 (ARM-ADS)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CameraModule
  c flags: Optim=1 OneElfS=1 wLevel=2
  c misc: --C99
  c include: .\include;.\include\drivers\cmsis;.\include\drivers\cmsis\device;.\include\drivers\hal;.\include\drivers\hal\legacy;.\include\peripherals;.\include\drivers\camera;.\include\drivers\lcd;.\include\rtos
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group application
    ./source/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c dsp.c
    ./include/: dsp.h
  group configs
    ./include/: hardware.h headers.h stm32f4xx_hal_conf.h
  group hal library
    ./source/drivers/hal/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_fmc.c stm32f4xx_hal_sdram.c
  group peripherals
    ./source/peripherals/: dcmi.c dma.c gpio.c i2c.c spi.c fmc.c
  group cmsis
    ./source/drivers/cmsis/device/: system_stm32f4xx.c startup_stm32f429xx.s
  group camera
    ./source/drivers/camera/: ov7670.c
  group lcd
    ./source/drivers/lcd/: fonts.c ili9341.c
  group rtos
    ./source/rtos/: cmsis_os.c croutine.c event_groups.c freertos.c list.c queue.c tasks.c timers.c
    ./source/rtos/portable/MemMang/: heap_4.c
    ./source/rtos/portable/RVDS/ARM_CM4F/: port.c
